v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
L 4 260 40 290 40 {}
L 4 290 10 290 40 {}
L 4 290 10 320 10 {}
L 4 290 -10 320 -10 {}
L 4 290 -20 290 -10 {}
L 4 -120 -20 290 -20 {}
L 4 -20 40 20 40 {}
L 4 120 40 160 40 {}
L 4 70 0 210 -0 {}
L 4 -70 0 70 0 {}
L 4 -70 80 70 80 {}
L 4 70 80 210 80 {}
L 4 210 -30 210 -0 {}
L 4 210 -30 360 -30 {}
L 4 -120 -20 -120 40 {}
L 4 -140 -20 -120 -20 {}
L 4 400 0 420 0 {}
L 4 350 30 350 80 {}
L 4 350 80 360 80 {}
L 4 210 80 350 80 {}
L 4 380 0 400 -0 {}
C {/home/madvlsi/madvlsi/mp1/xschem/inv.sym} -70 40 0 0 {name=X1}
C {/home/madvlsi/madvlsi/mp1/xschem/inv.sym} 70 40 0 0 {name=X2}
C {/home/madvlsi/madvlsi/mp1/xschem/inv.sym} 210 40 0 0 {name=X3}
C {iopin.sym} 360 80 0 0 {name=p1 lab=VN}
C {iopin.sym} 360 -30 0 0 {name=p2 lab=VP}
C {opin.sym} 420 0 0 0 {name=p3 lab=Y}
C {ipin.sym} -140 -20 0 0 {name=p4 lab=A}
C {AND2.sym} 350 0 0 0 {}
